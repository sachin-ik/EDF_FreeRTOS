# Keil uVision project Simple-FreeRTOS-Demo.uvproj, settings and files
target Simple-FreeRTOS-Demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Simple-FreeRTOS-Demo
  c flags: Optim=1
  c include: .;.\FreeRTOS-Source\include;.\FreeRTOS-Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_MPS_CM3.s
  group Demo-files
    ./: FreeRTOSConfig.h testEDF.c
  group FreeRTOS-Source
    ./FreeRTOS-Source/: tasks.c list.c queue.c
    ./FreeRTOS-Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS-Source/portable/MemMang/: heap_1.c
